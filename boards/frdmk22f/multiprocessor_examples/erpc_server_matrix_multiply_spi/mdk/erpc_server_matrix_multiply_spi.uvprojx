# Keil uVision project erpc_server_matrix_multiply_spi.uvprojx, settings and files
target erpc_server_matrix_multiply_spi Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: erpc_server_matrix_multiply_spi.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../erpc_common/erpc_matrix_multiply/service;../../erpc_common;../../../../../middleware/multicore_2.2.0/erpc/erpc_c/infra;../../../../../middleware/multicore_2.2.0/erpc/erpc_c/port;../../../../../middleware/multicore_2.2.0/erpc/erpc_c/setup;../../../../../middleware/multicore_2.2.0/erpc/erpc_c/transports;../../../../../middleware/multicore_2.2.0/erpc/erpcgen/src;../../..;../../../../../devices/MK22F51212/drivers;../../../../../devices/MK22F51212/utilities;../../../../../devices/MK22F51212
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MK22F51212/arm/: startup_MK22F51212.s
    ../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK22F51212/drivers/: fsl_dspi.h fsl_dspi.c fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group erpc-setup
    ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/setup/: erpc_setup_dspi_slave.cpp erpc_setup_mbf_dynamic.cpp erpc_server_setup.h erpc_server_setup.cpp erpc_transport_setup.h erpc_mbf_setup.h
  group erpc-transports
    ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/transports/: dspi_slave_transport.h dspi_slave_transport.cpp
  group erpc-infra
    ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/infra/: framed_transport.h framed_transport.cpp simple_server.h simple_server.cpp server.h server.cpp erpc_version.h codec.h basic_codec.h transport.h message_buffer.h erpc_common.h manually_constructed.h basic_codec.cpp message_buffer.cpp
  group erpc-port
    ../../../../../middleware/multicore_2.2.0/erpc/erpc_c/port/: erpc_port.h erpc_port_stdlib.cpp erpc_config_internal.h
  group source
    ../: main_server.c erpc_config.h
  group erpc
    ../../erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
  group erpc-service
    ../../erpc_common/erpc_matrix_multiply/service/: erpc_matrix_multiply.erpc erpc_matrix_multiply.h erpc_matrix_multiply_server.h erpc_matrix_multiply_server.cpp
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
target erpc_server_matrix_multiply_spi Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: erpc_server_matrix_multiply_spi.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
